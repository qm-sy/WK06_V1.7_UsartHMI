# Keil uVision project WK06_V1.7_UsartHMI.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: WK06_V1.7_UsartHMI +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\Inc;..\Core\Inc;..\Drivers;..\Emembed\Inc;..\Middlewares;..\SYSTEM\Inc
  group Source Group 1
    ./: STARTUP.A51
  group Core
    ../Core/Src/: adc.c eeprom.c gpio.c main.c pwm.c timer.c uart.c
  group BSP
    ../BSP/Src/: eeprom_crl.c ntc.c power_crl.c serial_port.c
  group SYSTEM
    ../SYSTEM/Src/: delay.c
  group Emembed
    ../Emembed/Src/: modbus_rtu.c
